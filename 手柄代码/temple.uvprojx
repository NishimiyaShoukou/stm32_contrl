# Keil uVision project temple.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F103C8 HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temple +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dma;.\APP\rtc;.\APP\OLED;.\APP\iic;.\APP;.\APP\joy;.\APP\NRF24L01;.\APP\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./User/: stm32f10x_it.c main.c
  group startup
    ./User/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
  group cmsis
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ./APP/led/: led.c
    ./APP/OLED/: oled.c
    ./APP/iic/: iic.c
    ./APP/: pwm.c timer.c Control_Task.c
    ./APP/key/: key.c
    ./APP/exti/: exti.c
    ./APP/joy/: joy.c
    ./APP/SPI/: spi.c
    ./APP/NRF24L01/: 24l01.c
  group public
    ./public/: system.c SysTick.c usart.c
